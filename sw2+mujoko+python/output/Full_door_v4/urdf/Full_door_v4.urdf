Commit message: fixed door mujoko model did literature survey prepared review doc

File: sw2+mujoko+python/output/Full_door_v4/urdf/Full_door_v4.urdf (robot description, URDF)
Before this commit: robot Full_door_v4, 4 links, 3 joints
Links:
- link handle_1: mass 4.71892 -> 4.29491
